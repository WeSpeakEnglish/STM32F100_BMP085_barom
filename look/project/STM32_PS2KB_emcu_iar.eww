<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32_PS2KB_emcu_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>


