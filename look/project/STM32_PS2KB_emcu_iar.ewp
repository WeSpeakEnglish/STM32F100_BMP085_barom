# IAR project STM32_PS2KB_emcu_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\inc&src\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_PS2KB_emcu_iar.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32_PS2KB_emcu_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../inc&src/: gpio_emcu.c hd44780_emcu.c interrupt_emcu.c main.c PS2KB_emcu.c startup_stm32f10x_ld_vl.s system_stm32f10x.c
